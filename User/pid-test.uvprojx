# Keil uVision project pid-test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pid-test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\STM32F4xx_StdPeriph_Driver\STM32F4xx_StdPeriph_Driver\inc;..\Core;..\BSP;..\User;..\CMSIS_DSP\Include;..\CMSIS_DSP\Include\dsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c
  group user-api
    ./: upctrl.c
  group Bsp
    ../BSP/: adc.c dac.c delay.c led.c tim.c oled.c sys.c
  group Core
    ../Core/: stm32f4xx_assert.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group M4-Lib
    ../STM32F4xx_StdPeriph_Driver/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS_DSP/InterpolationFunctions/: arm_bilinear_interp_f32.c arm_linear_interp_f32.c arm_spline_interp_f32.c arm_spline_interp_init_f32.c
